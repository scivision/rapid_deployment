<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dual_diagnostic</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_toggle</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq0</value></param>
<param><key>value</key><value>150e6</value></param>
<param><key>gui_hint</key><value>3, 1, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1000e3</value></param>
<param><key>stop</key><value>500e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq1</value></param>
<param><key>value</key><value>400e6</value></param>
<param><key>gui_hint</key><value>4, 1, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1000e3</value></param>
<param><key>stop</key><value>500e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>max_intensity</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>gui_hint</key><value>3, 2, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>min_intensity</value></param>
<param><key>value</key><value>-115</value></param>
<param><key>gui_hint</key><value>4, 2, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_toggle</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>3, 0, 2, 1</value></param>
<param><key>label</key><value>Run</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_offset0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_offset1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>update_period</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>5, 1, 1, 1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>dual_diagnostic_tabs@1 : 0, 1, 1, 1</value></param>
<param><key>label</key><value>Channel 1</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_3</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>dual_diagnostic_tabs@1 : 0, 3, 1, 1</value></param>
<param><key>label</key><value>Channel 2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>open</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>open</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>dual_diagnostic_tabs</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 3</value></param>
<param><key>label0</key><value>Frequency</value></param>
<param><key>label1</key><value>Waterfall</value></param>
<param><key>label2</key><value>TIme</value></param>
<param><key>label3</key><value>IQ Constellation</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>dual_diagnostic_tabs@3 : 0, 0, 1, 2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>0.7</value></param>
<param><key>label1</key><value>Channel 1</value></param>
<param><key>alpha2</key><value>0.7</value></param>
<param><key>label2</key><value>Channel 2</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>xmin</key><value>-1</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>-1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq0</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>dual_diagnostic_tabs@0 : 0, 0, 1, 2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>0.7</value></param>
<param><key>label1</key><value>Channel 1</value></param>
<param><key>alpha2</key><value>0.7</value></param>
<param><key>label2</key><value>Channel 2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>max_intensity</value></param>
<param><key>ymin</key><value>min_intensity</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>dual_diagnostic_tabs@2 : 0, 0, 1, 2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>0.7</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Channel 1 (real)</value></param>
<param><key>alpha2</key><value>0.7</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Channel 1 (imag)</value></param>
<param><key>alpha3</key><value>0.7</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Channel 2 (real)</value></param>
<param><key>alpha4</key><value>0.7</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Channel 2 (imag)</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq0</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>dual_diagnostic_tabs@1 : 1, 0, 1, 2</value></param>
<param><key>int_max</key><value>max_intensity</value></param>
<param><key>int_min</key><value>min_intensity</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value></value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq1</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>dual_diagnostic_tabs@1 : 1, 2, 1, 2</value></param>
<param><key>int_max</key><value>max_intensity</value></param>
<param><key>int_min</key><value>min_intensity</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value></value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq0, tune_offset0)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>uhd.tune_request(center_freq1, tune_offset1)</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>addr=192.168.30.2</value></param>
<param><key>sd_spec0</key><value>"A:RX1 A:RX2"</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>stream_args</key><value>peak=1.0</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_valve_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_valve_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_valve_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_valve_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
